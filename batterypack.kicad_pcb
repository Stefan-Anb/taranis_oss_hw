# Repository Stefan-Anb/taranis_oss_hw (continued)

## KiCad design batterypack.kicad_pcb (continued)

Board: 2 copper layers, 283 parts (0 on the bottom side), 176 nets, no tracks yet.

Other parts of the board:
C44: 100n; C_0402_1005Metric
D7: PESD3V3U1UA,115; D_SOD-323
J13: Conn_01x06; JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
R65, R78: 2k; R_0402_1005Metric
TP10: TestPoint_Small; TestPoint_Pad_D1.0mm

Their connections:
+3.3V: R65.2; also elsewhere on the board
/5VSW: J13.6; also elsewhere on the board
/CANH: J13.2; also elsewhere on the board
/CANL: J13.1; also elsewhere on the board
/ESP32/Key_uc: C44.2, R78.2; also elsewhere on the board
/GPIO1: J13.5; also elsewhere on the board
/KEY: D7.1 (K), J13.4, R65.1, R78.1
